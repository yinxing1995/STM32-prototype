system.cpu CORTEXM3
system.up
